# Keil uVision project ucosii.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucosii
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xx
  c include: .\app;.\core;.\ports;.\user;.\Library;.\Hardware;.\Start;.\SystemView\cfg;.\SystemView\OS;.\SystemView\segger;.\SystemView\OS\Config\Cortex-M;.\SystemView\OS\Config;.\SystemView\segger\Syscalls;.\Time_sched
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ./app/: app_cfg.h os_cfg.h app_hooks.c
  group Start
    ./Start/: core_cm4.h core_cmFunc.h startup.s stm32f4xx.h system.c system.h
  group Library
    ./Library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.c stm32f4xx_fmc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group Hardware
    ./Hardware/: GY86.c GY86.h GY86_Reg.h MS5611_CMD.h OLED.c OLED.h OLED_Font.h PPM.c PPM.h pwm.c pwm.h usart.c usart.h Final.c Final.h PID.c PID.h Madgwick.c Madgwick.h
  group Time_sched
    ./Time_sched/: Delay.c dwt_time.c dwt_time.h tim_sched.c tim_sched.h
    ./TIme_sched/: Delay.h
  group ports
    ./ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group core
    ./core/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
  group user
    ./user/: main.c
    ./Hardware/: mytasks.c mytasks.h
  group Trace_cfg
    ./SystemView/cfg/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
  group Trace_OS
    ./SystemView/OS/: os_trace_events.h SEGGER_SYSVIEW_uCOSII.c
    ./SystemView/OS/Config/: os_cfg_trace.h
    ./SystemView/OS/Config/Cortex-M/: SEGGER_SYSVIEW_Config_uCOSII.c
  group Trace_segger
    ./SystemView/segger/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
